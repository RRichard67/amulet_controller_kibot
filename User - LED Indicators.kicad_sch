File: User - LED Indicators.kicad_sch (KiCad schematic)
At the start: 10 parts, among them Q7 PMV90ENER, Q8 PMV90ENER

Commit message: Kicad 10
Parts:
- renumbered R18 to R21, R18 to R24
