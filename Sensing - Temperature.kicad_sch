File: Sensing - Temperature.kicad_sch (KiCad schematic)
At the start: 9 parts

Commit message: Kicad 10
Parts:
- renumbered D17 to D14, D17 to D15, R44 to R28
